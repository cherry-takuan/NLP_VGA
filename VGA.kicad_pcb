# Repository cherry-takuan/NLP_VGA

## KiCad design VGA.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16: C; C_Disc_D7.0mm_W2.5mm_P5.00mm
C19: C; CP_Radial_D5.0mm_P2.50mm
D1: LED; LED_D3.0mm
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3mm_Pad
R8: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: 74HC04; DIP-14_W7.62mm
U2: 74HC74; DIP-14_W7.62mm
U3: 74HC02; DIP-14_W7.62mm

Connections:
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C19.2, H1.1, H2.1, H3.1, H4.1, R8.2, U1.7 (GND), U2.7 (GND), U3.7 (GND); also elsewhere on the board
unnamed: D1.1 (K), R8.1
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C19.1, D1.2 (A), U1.14 (VCC), U2.14 (VCC), U3.14 (VCC); also elsewhere on the board

Parts:
C17, C18: 22p; C_Disc_D3.0mm_W1.6mm_P2.50mm
J1: DB15_Female_HighDensity_MountingHoles; DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
JP1: Jumper_3_Bridged12; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
R1: 1M; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical
R2, R3, R4: 200; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12, R13, R14, R15, R16, R17, R18: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
RN1: R_Network04; R_Array_SIP5
SW1: SW_DIP_x03; SW_DIP_SPSTx03_Piano_10.8x9.18mm_W7.62mm_P2.54mm
SW2: SW_DIP_x04; SW_DIP_SPSTx04_Piano_10.8x11.72mm_W7.62mm_P2.54mm
TP1, TP2, TP3: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm
U1: 74HC04; DIP-14_W7.62mm
U2: 74HC74; DIP-14_W7.62mm
U4: CD74HC08; DIP-14_W7.62mm
U5, U8: 4040; DIP-16_W7.62mm
U6: 74HC273; DIP-20_W7.62mm
U7, U12: SST39SF010A; DIP-32_W15.24mm
U9, U10: 74LS195; DIP-16_W7.62mm
U11: TC551001; DIP-32_W15.24mm
Y1: 25M; Crystal_HC18-U_Vertical

Connections:
B: J1.3, R4.2, R7.2
CG_data0: U9.4 (P0), U12.21 (Q7)
CG_data1: U9.5 (P1), U12.20 (Q6)
CG_data2: U9.6 (P2), U12.19 (Q5)
CG_data3: U9.7 (P3), U12.18 (Q4)
CG_data4: U10.4 (P0), U12.17 (Q3)
CG_data5: U10.5 (P1), U12.15 (Q2)
CG_data6: U10.6 (P2), U12.14 (Q1)
CG_data7: U10.7 (P3), U12.13 (Q0)
CLK: U2.9 (Q), U5.10 (CLK), U6.11 (Cp), U9.10 (CP), U10.10 (CP)
CRAM_Addr0: U11.12 (A0); also elsewhere on the board
CRAM_Addr1: U11.11 (A1); also elsewhere on the board
CRAM_Addr2: U11.10 (A2); also elsewhere on the board
CRAM_Addr3: U11.23 (A10); also elsewhere on the board
CRAM_Addr4: U11.9 (A3); also elsewhere on the board
CRAM_Addr5: U11.8 (A4); also elsewhere on the board
CRAM_Addr6: U11.7 (A5); also elsewhere on the board
CRAM_Addr7: U11.26 (A9); also elsewhere on the board
CRAM_Addr8: U11.6 (A6); also elsewhere on the board
CRAM_Addr9: U11.27 (A8); also elsewhere on the board
CRAM_Addr10: U11.5 (A7); also elsewhere on the board
C_DATA0: R11.1, U11.13 (Q0), U12.5 (A7); also elsewhere on the board
C_DATA1: R12.1, U11.14 (Q1), U12.6 (A6); also elsewhere on the board
C_DATA2: R13.1, U11.15 (Q2), U12.7 (A5); also elsewhere on the board
C_DATA3: R14.1, U11.21 (Q7), U12.8 (A4); also elsewhere on the board
C_DATA4: R15.1, U11.20 (Q6), U12.9 (A3); also elsewhere on the board
C_DATA5: R16.1, U11.19 (Q5), U12.10 (A2); also elsewhere on the board
C_DATA6: R17.1, U11.18 (Q4), U12.11 (A1); also elsewhere on the board
C_DATA7: R18.1, U11.17 (Q3), U12.12 (A0); also elsewhere on the board
F_mode0: RN1.5 (R4), SW2.5, U12.25 (A11)
F_mode1: RN1.4 (R3), SW2.6, U12.4 (A12)
F_mode2: RN1.3 (R2), SW2.7, U12.28 (A13)
F_mode3: RN1.2 (R1), SW2.8, U12.29 (A14)
G: J1.2, R3.2, R6.2
GND: C17.2, C18.2, J1.0, J1.5, JP1.3 (B), R5.1, R6.1, R7.1, RN1.1 (common), U1.11, U4.7 (GND), U5.8 (VSS), U6.10 (GND), U7.2 (A16), U7.16 (GND), U7.22 (~CE), U7.24 (~OE), U8.8 (VSS), U9.2 (J), U9.3 (~K), U9.8 (GND), U10.8 (GND), U11.2 (A16), U11.3 (A14), U11.4 (A12), U11.16 (GND), U11.22 (~CS1), U12.2 (A16), U12.3 (A15), U12.16 (GND), U12.22 (~CE), U12.24 (~OE); also elsewhere on the board
H_Addr0: U5.5 (Q3), U7.12 (A0); also elsewhere on the board
H_Addr1: U5.3 (Q4), U7.11 (A1); also elsewhere on the board
H_Addr2: U5.2 (Q5), U7.10 (A2); also elsewhere on the board
H_Addr3: U5.4 (Q6), U7.9 (A3); also elsewhere on the board
H_Addr4: U5.13 (Q7), U7.8 (A4); also elsewhere on the board
H_Addr5: U5.12 (Q8), U7.7 (A5); also elsewhere on the board
H_COUNT_RS: U4.5, U6.19 (Q7)
H_Sync: J1.13, TP1.1, U6.12 (Q4)
unnamed: C17.1, R1.1, U1.1, Y1.1
unnamed: C18.1, R1.2, U1.2, U1.3, Y1.2
unnamed: JP1.2 (C), U11.25 (A11)
unnamed: R2.1, SW1.6
unnamed: R3.1, SW1.5
unnamed: R4.1, SW1.4
unnamed: SW1.1, SW1.2, SW1.3, U4.3
unnamed: U1.4, U2.11 (C)
unnamed: U1.6, U1.9
unnamed: U4.6, U5.11 (Reset)
unnamed: U4.9, U5.9 (Q0)
unnamed: U4.10, U4.11
unnamed: U4.4, U4.12, U5.6 (Q2)
unnamed: U4.13, U5.7 (Q1)
unnamed: U6.3 (D0), U7.21 (Q7)
unnamed: U6.4 (D1), U7.20 (Q6)
unnamed: U6.7 (D2), U7.19 (Q5)
unnamed: U6.8 (D3), U7.18 (Q4)
unnamed: U6.13 (D4), U7.17 (Q3)
unnamed: U6.14 (D5), U7.15 (Q2)
unnamed: U6.17 (D6), U7.14 (Q1)
unnamed: U6.18 (D7), U7.13 (Q0)
unnamed: U9.12 (Q3), U10.2 (J), U10.3 (~K)
unnamed: U2.6 (~Q), U9.9 (~PE), U10.9 (~PE)
unnamed: U4.1, U10.12 (Q3)
R: J1.1, R2.2, R5.2
VCC: R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, SW2.1, SW2.2, SW2.3, SW2.4, U1.5, U2.1 (~R), U2.4 (~S), U2.10 (~S), U2.13 (~R), U4.14 (VCC), U5.16 (VDD), U6.1 (~Mr), U6.20 (VCC), U7.31 (~WE), U7.32 (VDD), U8.16 (VDD), U9.1 (~MR), U9.16 (VCC), U10.16 (VCC), U11.28 (A13), U11.30 (CE2), U11.31 (A15), U11.32 (VCC), U12.31 (~WE), U12.32 (VDD); also elsewhere on the board
V_Addr0: U7.6 (A6), U8.9 (Q0)
V_Addr1: U7.5 (A7), U8.7 (Q1), U12.27 (A8)
V_Addr2: U7.27 (A8), U8.6 (Q2), U12.26 (A9)
V_Addr3: U7.26 (A9), U8.5 (Q3), U12.23 (A10)
V_Addr4: U7.23 (A10), U8.3 (Q4); also elsewhere on the board
V_Addr5: U7.25 (A11), U8.2 (Q5); also elsewhere on the board
V_Addr6: U7.4 (A12), U8.4 (Q6); also elsewhere on the board
V_Addr7: U7.28 (A13), U8.13 (Q7); also elsewhere on the board
V_Addr8: U7.29 (A14), U8.12 (Q8); also elsewhere on the board
V_Addr9: U7.3 (A15), U8.14 (Q9)
V_COUNT_CLK: U6.15 (Q5), U8.10 (CLK)
V_COUNT_RS: U6.16 (Q6), U8.11 (Reset)
V_Sync: J1.14, TP2.1, U6.9 (Q3)
Visible: TP3.1, U4.2, U6.6 (Q2)
/CLK: U2.3 (C), U2.8 (~Q), U2.12 (D)
/PE: U2.2 (D), U4.8
~DE: U10.1 (~MR); also elsewhere on the board
~OE: U11.24 (~OE); also elsewhere on the board
~WE: JP1.1 (A), U11.29 (RW); also elsewhere on the board

Notes on the sheet:
V Counter
timing generator
Char RAM
M58725 ←→ TC551001
CLK
H Counter
Decode ROM
80ns
OUTPUT

Parts:
D2, D3: LED; LED_D3.0mm
J2, J3: Conn_02x20_Odd_Even; PinSocket_2x20_P2.54mm_Vertical
R9, R10: R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: 74HC04; DIP-14_W7.62mm
U3: 74HC02; DIP-14_W7.62mm
U13, U14, U15: 74HC244; DIP-20_W7.62mm
U16: 74LS245; DIP-20_W7.62mm

Connections:
Addr0: J3.1, U15.11 (2A3)
Addr1: J3.3, U15.13 (2A2)
Addr2: J3.5, U15.15 (2A1)
Addr3: J3.7, U15.17 (2A0)
Addr4: J3.9, U14.11 (2A3)
Addr5: J3.11, U14.13 (2A2)
Addr6: J3.13, U14.15 (2A1)
Addr7: J3.15, U14.17 (2A0)
Addr8: J3.17, U13.11 (2A3)
Addr9: J3.19, U13.13 (2A2)
Addr10: J3.21, U13.15 (2A1)
CRAM_Addr0: U15.9 (2Y3), U15.12 (1Y3); also elsewhere on the board
CRAM_Addr1: U15.7 (2Y2), U15.14 (1Y2); also elsewhere on the board
CRAM_Addr2: U15.5 (2Y1), U15.16 (1Y1); also elsewhere on the board
CRAM_Addr3: U15.3 (2Y0), U15.18 (1Y0); also elsewhere on the board
CRAM_Addr4: U14.9 (2Y3), U14.12 (1Y3); also elsewhere on the board
CRAM_Addr5: U14.7 (2Y2), U14.14 (1Y2); also elsewhere on the board
CRAM_Addr6: U14.5 (2Y1), U14.16 (1Y1); also elsewhere on the board
CRAM_Addr7: U14.3 (2Y0), U14.18 (1Y0); also elsewhere on the board
CRAM_Addr8: U13.9 (2Y3), U13.12 (1Y3); also elsewhere on the board
CRAM_Addr9: U13.7 (2Y2), U13.14 (1Y2); also elsewhere on the board
CRAM_Addr10: U13.5 (2Y1), U13.16 (1Y1); also elsewhere on the board
C_DATA0: U16.18 (B0); also elsewhere on the board
C_DATA1: U16.17 (B1); also elsewhere on the board
C_DATA2: U16.16 (B2); also elsewhere on the board
C_DATA3: U16.15 (B3); also elsewhere on the board
C_DATA4: U16.14 (B4); also elsewhere on the board
C_DATA5: U16.13 (B5); also elsewhere on the board
C_DATA6: U16.12 (B6); also elsewhere on the board
C_DATA7: U16.11 (B7); also elsewhere on the board
GND: J2.38, J2.40, J3.38, J3.40, U13.2 (1A0), U13.10 (GND), U13.17 (2A0), U14.10 (GND), U15.10 (GND), U16.10 (GND); also elsewhere on the board
H_Addr0: U15.8 (1A3); also elsewhere on the board
H_Addr1: U15.6 (1A2); also elsewhere on the board
H_Addr2: U15.4 (1A1); also elsewhere on the board
H_Addr3: U15.2 (1A0); also elsewhere on the board
H_Addr4: U14.8 (1A3); also elsewhere on the board
H_Addr5: U14.6 (1A2); also elsewhere on the board
IO_BUS0: J2.2, U16.2 (A0)
IO_BUS1: J2.4, U16.3 (A1)
IO_BUS2: J2.6, U16.4 (A2)
IO_BUS3: J2.8, U16.5 (A3)
IO_BUS4: J2.10, U16.6 (A4)
IO_BUS5: J2.12, U16.7 (A5)
IO_BUS6: J2.14, U16.8 (A6)
IO_BUS7: J2.16, U16.9 (A7)
unnamed: D2.1 (K), R9.1
unnamed: D3.1 (K), R10.1
unnamed: U1.12, U13.1 (1OE), U14.1 (1OE), U15.1 (1OE)
unnamed: U3.2, U3.3, U3.4
unnamed: U3.10, U3.11
unnamed: U13.3 (2Y0), U13.18 (1Y0)
VCC: D2.2 (A), D3.2 (A), J3.37, J3.39, U13.20 (VCC), U14.20 (VCC), U15.20 (VCC), U16.20 (VCC); also elsewhere on the board
V_Addr4: U14.4 (1A1); also elsewhere on the board
V_Addr5: U14.2 (1A0); also elsewhere on the board
V_Addr6: U13.8 (1A3); also elsewhere on the board
V_Addr7: U13.6 (1A2); also elsewhere on the board
V_Addr8: U13.4 (1A1); also elsewhere on the board
~DE: J2.13, U1.13, U3.6, U3.9, U3.12, U13.19 (2OE), U14.19 (2OE), U15.19 (2OE), U16.19 (CE); also elsewhere on the board
~OE: R10.2, U3.13, U16.1 (A->B); also elsewhere on the board
~RD: J2.34, U3.8
~WE: R9.2, U3.1; also elsewhere on the board
~WR_CLK: J2.35, U3.5

Notes on the sheet:
注:ピンヘッダとピンソケットでフットプリントの左右が違う
A_SEL -> RD Y_SEL -> WE

Board: 2 copper layers, 117.5 x 99.7 mm, 71 parts (9 on the bottom side), 117 nets.

File production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C13, C14, C15, C16, C2, C3, C4, C5, C6, C7, C8, C9",C_Disc_D7.0mm_W2.5mm_P5.00mm,16,C,
"C17, C18",C_Disc_D3.0mm_W1.6mm_P2.50mm,2,22p,
C19,CP_Radial_D5.0mm_P2.50mm,1,C,
"D1, D2, D3",LED_D3.0mm,3,LED,
"H1, H2, H3, H4",MountingHole_3mm_Pad,4,MountingHole_Pad,
J1,DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03mm_Housed_MountingHolesOffset4.94mm,1,DB15_Female_HighDensity_MountingHoles,
"J2, J3",PinSocket_2x20_P2.54mm_Vertical,2,Conn_02x20_Odd_Even,
JP1,SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm,1,Jumper_3_Bridged12,
R1,R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Vertical,1,1M,
"R10, R11, R12, R13, R14, R15, R16, R17, R18, R8, R9",0603,11,R,
"R2, R3, R4",0603,3,200,
"R5, R6, R7",0603,3,470,
RN1,R_Array_SIP5,1,R_Network04,
SW1,SW_DIP_SPSTx03_Piano_10.8x9.18mm_W7.62mm_P2.54mm,1,SW_DIP_x03,
SW2,SW_DIP_SPSTx04_Piano_10.8x11.72mm_W7.62mm_P2.54mm,1,SW_DIP_x04,
"TP1, TP2, TP3",TestPoint_THTPad_D1.0mm_Drill0.5mm,3,TestPoint,
U1,DIP-14_W7.62mm,1,74HC04,
"U10, U9",DIP-16_W7.62mm,2,74LS195,
U11,DIP-32_W15.24mm,1,TC551001,
"U12, U7",DIP-32_W15.24mm,2,SST39SF010A,
"U13, U14, U15",DIP-20_W7.62mm,3,74HC244,
U16,DIP-20_W7.62mm,1,74LS245,
U2,DIP-14_W7.62mm,1,74HC74,
U3,DIP-14_W7.62mm,1,74HC02,
U4,DIP-14_W7.62mm,1,CD74HC08,
"U5, U8",DIP-16_W7.62mm,2,4040,
U6,DIP-20_W7.62mm,1,74HC273,
Y1,Crystal_HC18-U_Vertical,1,25M,

## Commit log

2025-02-02 暫定回路
2025-02-04 だいたい完成
2025-02-04 フォントテーブル追加
2025-02-04 システムROM追加
2025-02-04 フォントテーブル修正
2025-02-06 信号生成部設計完了
2025-02-06 電源ライン増強他
2025-02-06 内部バスプルアップ追加他/基板製造バージョン
2025-02-28 VGAの入出力インターフェイス修正
2025-02-28 VRAMアクセス中の出力イネーブルを追加
